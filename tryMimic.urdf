Commit message: mixed

File: tryMimic.urdf (robot description, URDF)
Before this commit: robot parallel_link, 4 links, 3 joints
Links:
- removed link link3
Joints:
- removed joint joint2
